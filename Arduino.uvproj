# Keil uVision project Arduino.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Arduino +hex
  group User
    ./: demo.cpp
  group Core
    ../hardware/stm32/1.7.0/cores/arduino/: syscalls.c
    ./: core.lib
  group variant
    ../hardware/stm32/1.7.0/variants/PILL_F103XX/: PeripheralPins.c variant.cpp
